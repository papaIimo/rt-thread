# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32MP157A_M4 ST STM32MP157A_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_CM4; NO_ATOMIC_64_SUPPORT; METAL_INTERNAL; METAL_MAX_DEVICE_REGIONS=2; VIRTIO_SLAVE_ONLY; STM32MP157Axx; __LOG_TRACE_IO_; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\components\dfs\filesystems\devfs; ..\..\..\components\finsh; ..\libraries\STM32MPxx_HAL\CMSIS\Core\Include; ..\..\..\components\drivers\include; board\ports\OpenAMP\open-amp\lib\include; board\ports\audio; ..\..\..\components\libc\compilers\common; board\ports\OpenAMP\virtual_driver; board\CubeMX_Config\CM4\Inc; .; ..\libraries\HAL_Drivers\config; board; ..\libraries\HAL_Drivers; board\ports; board\ports\OpenAMP\libmetal\lib\include; ..\libraries\STM32MPxx_HAL\CMSIS\Include; ..\..\..\components\dfs\filesystems\elmfat; board\ports\OpenAMP; ..\..\..\include; ..\libraries\STM32MPxx_HAL\CMSIS\Device\ST\STM32MP1xx\Include; ..\..\..\libcpu\arm\common; ..\..\..\libcpu\arm\cortex-m4; applications; ..\..\..\components\dfs\include; ..\libraries\STM32MPxx_HAL\STM32MP1xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.bin
  ILINK.IlinkOutputFile: RT-Thread-STM32MP1_CM4.elf
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: showmem.c div0.c backtrace.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_iar.S
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/sdio/: mmc.c sd.c block_dev.c sdio.c mmcsd_core.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: dataqueue.c completion.c ringbuffer.c pipe.c workqueue.c ringblk_buf.c waitqueue.c
  group Drivers
    board/ports/OpenAMP/libmetal/lib/: log.c io.c st_device.c dma.c shmem.c init.c version.c
    board/CubeMX_Config/CM4/Src/: mbox_ipcc.c rsc_table.c openamp_log.c openamp.c stm32mp1xx_hal_msp.c
    board/ports/OpenAMP/libmetal/lib/system/generic/: generic_device.c condition.c generic_irq.c generic_init.c generic_io.c generic_shmem.c generic_time.c
    board/ports/OpenAMP/: drv_openamp.c
    board/ports/OpenAMP/open-amp/lib/remoteproc/: elf_loader.c remoteproc.c rsc_table_parser.c remoteproc_virtio.c
    board/ports/: drv_sdio.c
    board/CubeMX_Config/Common/System/: system_stm32mp1xx.c
    board/ports/OpenAMP/virtual_driver/: virt_uart.c
    board/ports/OpenAMP/open-amp/lib/virtio/: virtio.c virtqueue.c
    board/ports/OpenAMP/libmetal/lib/system/generic/cortexm/: sys.c
    board/: board.c
    board/ports/OpenAMP/open-amp/lib/rpmsg/: rpmsg_virtio.c rpmsg.c
    ../libraries/STM32MPxx_HAL/CMSIS/Device/ST/STM32MP1xx/Source/Templates/iar/: startup_stm32mp15xx.s
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group Filesystem
    ../../../components/dfs/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
    ../../../components/dfs/filesystems/elmfat/: ff.c ffunicode.c dfs_elm.c
  group finsh
    ../../../components/finsh/: finsh_node.c finsh_parser.c cmd.c finsh_vm.c msh_file.c shell.c finsh_var.c finsh_compiler.c finsh_heap.c finsh_ops.c finsh_error.c finsh_token.c msh.c finsh_init.c
  group Kernel
    ../../../src/: object.c scheduler.c clock.c timer.c components.c device.c thread.c mempool.c irq.c kservice.c ipc.c idle.c memheap.c
  group libc
    ../../../components/libc/compilers/common/: time.c
  group Libraries
    ../libraries/STM32MPxx_HAL/STM32MP1xx_HAL_Driver/Src/: stm32mp1xx_hal_i2c_ex.c stm32mp1xx_hal_rcc.c stm32mp1xx_hal_spi.c stm32mp1xx_hal_exti.c stm32mp1xx_ll_sdmmc.c stm32mp1xx_hal_uart_ex.c stm32mp1xx_hal_dma_ex.c stm32mp1xx_ll_delayblock.c stm32mp1xx_hal_i2c.c stm32mp1xx_hal_rtc_ex.c stm32mp1xx_hal_rcc_ex.c stm32mp1xx_hal_gpio.c stm32mp1xx_hal_tim_ex.c stm32mp1xx_hal_hsem.c stm32mp1xx_hal_dac_ex.c stm32mp1xx_hal_rtc.c stm32mp1xx_hal_cortex.c stm32mp1xx_hal_pwr.c stm32mp1xx_hal_sd.c stm32mp1xx_hal_pwr_ex.c stm32mp1xx_hal_ipcc.c stm32mp1xx_hal_dma.c stm32mp1xx_hal.c stm32mp1xx_hal_adc_ex.c stm32mp1xx_hal_tim.c stm32mp1xx_hal_adc.c stm32mp1xx_hal_dac.c stm32mp1xx_hal_uart.c stm32mp1xx_hal_mdma.c
